# Keil uVision project qpc.uvprojx, settings and files
target Basic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F330R8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: basic +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F3X0,GD32F330,
  c include: ..\..\10-mcu\GD32F330;..\..\10-mcu\GD32F330\StdLib\Include;..\..\20-qpc\include;..\..\20-qpc\src;..\..\30-3rd\FreeRTOS\include;..\..\30-3rd\FreeRTOS;..\..\30-3rd\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\20-qpc\ports\freertos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../App/: main.c bsp.c led.c sm_led.c
  group Mcu
    ../../10-mcu/GD32F330/: system_gd32f3x0.c startup_gd32f3x0.s
  group Lib
    ../../10-mcu/GD32F330/StdLib/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Qpc
    ../../20-qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../20-qpc/: qpc_hooks.c
    ../../20-qpc/ports/freertos/: qf_port.c
  group FreeRTOS
    ../../30-3rd/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../30-3rd/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
