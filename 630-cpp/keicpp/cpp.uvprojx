# Keil uVision project cpp.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GD32F330RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cpp
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
