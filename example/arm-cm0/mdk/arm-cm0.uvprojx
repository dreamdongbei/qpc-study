# Keil uVision project arm-cm0.uvprojx, settings and files
target ARM-CM0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: arm-cm0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX,
  c include: ..\..\..\src;..\..\..\include;..\mcu;..\user;..\..\..\ports\arm-cm\qk\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/: ao_high.c ao_low.c main.c
  group qpc
    ../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../src/qk/: qk.c
  group qp_port
    ../../../ports/arm-cm/qk/arm/: qk_port.c
    ../user/: qk_port_svc.c
  group mcu
    ../mcu/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f0xx.s
